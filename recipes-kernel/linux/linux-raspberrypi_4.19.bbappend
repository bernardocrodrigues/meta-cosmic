FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://docker-config.cfg"